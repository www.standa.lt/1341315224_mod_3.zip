# Autodesk Inventor part: 8MRU-1-uzsakovui
## iProperties
Created: 2010-09
Part Number: 8MRU-1-uzsakovui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
